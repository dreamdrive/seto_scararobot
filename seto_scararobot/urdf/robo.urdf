Commit message: 20200126
瀬戸内ROSもくもく会の内容を反映

File: seto_scararobot/urdf/robo.urdf (robot description, URDF)
Before this commit: robot seto_scararobot, 4 links, 3 joints
Joints:
- joint arm1_to_arm2: axis 0 0 1 -> 0 0 -1
- joint base_to_arm1: axis 0 0 1 -> 0 0 -1
