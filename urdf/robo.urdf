Commit message: URDF修正
第2アームのオフセット値のミス修正

File: urdf/robo.urdf (robot description, URDF)
Before this commit: robot upper_body, 3 links, 2 joints
Joints:
- joint arm1_to_arm2: origin xyz=0 0.09 -0.004 rpy=0 0 0 -> xyz=0 0.09 -0.008 rpy=0 0 0
